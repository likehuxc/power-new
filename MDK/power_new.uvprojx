# Keil uVision project power_new.uvprojx, settings and files
target power_new_Debug (6240000::V6.24::ARMCLANG)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F460.1.0.12
  cpu: IROM1(0x00000000,0x80000) IROM2(0x03000C00,0x3FC) IRAM1(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: power_new +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __DEBUG,HC32F460,USE_DDL_DRIVER,
  c include: ..\;..\board;..\drivers;..\applications;..\communication;..\common\ring_buf;..\common\log;..\libraries\cmsis\Device\HDSC\hc32f4xx\Include;..\libraries\cmsis\Include;..\libraries\hc32_ll_driver\inc;..\components\freertos\include;..\components\freertos\portable\GCC\ARM_CM4F;..\components\saf_filter
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3c0
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\config\linker\HC32F460xE.sct
  link misc: --keep=*Handler
  group board
    ../board/: board.c
  group applications
    ../: main.c
    ../applications/: app.c battery.c battery_comm.c led.c light_ctrl.c uart_port.c eeprom.c bmi088.c power_manage.c ct02_port.c can_port.c charger.c
  group communication
    ../communication/: can.c uart1_dma.c spi.c uart4_dma.c i2c.c
  group drivers
    ../drivers/: drv_led.c adc.c din.c dout.c hw_ver.c rgb_led.c
  group components
    ../components/saf_filter/: saf_filter.c
  group common
    ../common/ring_buf/: ring_buf.c
    ../common/log/: log.c
  group freertos
    ../components/freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../components/freertos/portable/GCC/ARM_CM4F/: port.c
    ../components/freertos/portable/MemMang/: heap_4.c
  group libraries
    ../libraries/hc32_ll_driver/src/: hc32_ll.c hc32_ll_aos.c hc32_ll_adc.c hc32_ll_can.c hc32_ll_clk.c hc32_ll_dma.c hc32_ll_efm.c hc32_ll_fcg.c hc32_ll_fcm.c hc32_ll_gpio.c hc32_ll_i2c.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_keyscan.c hc32_ll_pwc.c hc32_ll_sram.c hc32_ll_tmr0.c hc32_ll_tmra.c hc32_ll_spi.c hc32_ll_usart.c hc32_ll_utility.c
  group cmsis
    ./: startup_hc32f460.s
    ../libraries/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f460.c
